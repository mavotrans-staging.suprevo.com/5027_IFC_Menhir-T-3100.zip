Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement []
File name: Project Number
Time: 2022-10-06T11:28:05
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190108_1515(x64) - Exporter 19.5.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 06 11:28:05 2022 * Host: HPZ2-TPLAT * Database: C:\Users\TESSAP~1\AppData\Local\Temp\{3B6BBA7C-3A48-4179-90B7-4035802B7513}\ifc * Database version: 5507 * Database creation date: Thu Oct 06 11:28:05 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Oct 06 11:28:05 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 06 11:28:05 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - BCB_ProjectFolder: C:\Users\Tessa Plat\OneDrive - Mavotrans\BIM T&D\3. Modellen Mavotrans\7. Oplegmaterialen\50-Oplegmaterialen constructief; Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; BCB_ProjectFolder: C:\Users\Tessa Plat\OneDrive - Mavotrans\BIM T&D\3. Modellen Mavotrans\7. Oplegmaterialen\50-Oplegmaterialen constructief; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Circle Head - Project Datum
Pset_AirSideSystemInformation - Name: Level 0
Pset_ProductRequirements - Name: Level 0; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 0; Structural: no
Other - Category: Levels; Family: Level: Circle Head - Project Datum; Family and Type: Level: Circle Head - Project Datum; Type: Level: Circle Head - Project Datum; Type Id: Level: Circle Head - Project Datum
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle: Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no

# IfcBuildingElementProxy: Artikelgroep | Article Group 5027, NLRSnl_28_GM_WPB_5027-Menhir T-3100_Mavotrans_R19:T-3120_150x150x20:329296
In: Level 0
Type - Description: Menhir T-3120 150x150x20mm; Classification: 28 (Default Classification); Material: Textile reinforced polychloroprene
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Breedte | Width (mm): 150 mm; Height: 20 mm; Hoogte | Height (mm): 20 mm; Lengte | Length (mm): 150 mm
Type - Fire Protection - Brandklasse | Fire classification: Niet getest | Not tested
Type - Forces - Bruikbaarheidsgrenstoestand (BGT) | Limit state: 338 kN; Geadviseerde max. drukspanning (karakteristieke waarde) | Advised max. compressive stress (characteristic value): 15 N/mm²
Type - Identity Data - Artikelnummer | Article number: Artikelgroep | Article Group 5027; Beschrijving | Description: Menhir T-3120 150x150x20mm; Laatste versie | Last version: 06-10-2022; Leverancier | Supplier: Mavotrans; Model: LOD400; NL-SfB code: 28; Opmerkingen | Comments: Verkrijgbaar in aangepaste maten. Op maat gemaakte aanbevelingen worden aangeboden door berekeningssoftware met gegeven parameters voor grootte en vereisten Materiaal is verouderingsbestendig en neemt geen vloeistoffen op | Available in custom sizes. Tailored recommendations are offered by calculation software with given size and requirements parameters Material is ageing resistant, and does not absorb liquids; Revisie | Revision: Rev0; Technische data | Technical data: Raadpleeg de gekoppelde webpagina | Please refer to linked URL; Tekenaar | Draftsman: D. Blokland; Type Name: T-3120_150x150x20; URL: https://mavotrans.nl/menhir-t-3100-textielgewapend.html https://mavotrans.nl/menhir-t-3100-textielgewapend.html https://mavotrans.nl/menhir-t-3100-textielgewapend.html; Voorwaarden | Disclaimer: Raadpleeg de gekoppelde webpagina en controleer voor gebruik van dit BIM-model op de laatst beschikbare revisie. De modellen, geometrie, data en parameterwaarden zijn met de grootste zorg bepaald. Desalniettemin bestaat de mogelijkheid op onjuistheden. Elke aansprakelijkheid hiervoor wordt van de hand gewezen, hoewel melding op prijs wordt gesteld. © Mavotrans, 2022 | Please refer to linked URL and check for the latest available model revision. The models, geometry and parameter values have been determined with the greatest care. Still, they are subject to errors. Mavotrans cannot be held liable in any way. However, we do appreciate your feedback. © Mavotrans, 2022
Type - Materials and Finishes - Materiaal | Material: Hoogwaardig textielgewapend polychloropreen montagerubber | High-grade textile reinforced polychloroprene
Type - Other - Category: Generic Models; Family Name: NLRSnl_28_GM_WPB_5027-Menhir T-3100_Mavotrans_R19; Length: 150 mm; Width: 150 mm
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_ProvisionForVoid - Width: 150 mm; Height: 20 mm
Pset_BuildingElementProxyCommon - Reference: NLRSnl_28_GM_WPB_5027-Menhir T-3100_Mavotrans_R19:T-3120_150x150x20; sets with these values: 2
Pset_ProvisionForVoid - Depth: 20 mm
Constraints - Level: Level: Level 0; Offset: 0 mm; Work Plane: Level : Level 0
Dimensions - Area: 0.0285 m2; Volume: 0.00045 m3
Other - Family: NLRSnl_28_GM_WPB_5027-Menhir T-3100_Mavotrans_R19: T-3120_150x150x20; Family and Type: NLRSnl_28_GM_WPB_5027-Menhir T-3100_Mavotrans_R19: T-3120_150x150x20; Schedule Level: Level: Level 0; Type: NLRSnl_28_GM_WPB_5027-Menhir T-3100_Mavotrans_R19: T-3120_150x150x20; Type Id: NLRSnl_28_GM_WPB_5027-Menhir T-3100_Mavotrans_R19: T-3120_150x150x20
Phasing - Phase Created: New Construction
